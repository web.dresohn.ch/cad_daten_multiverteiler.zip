Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Multiverteiler_MV10_D125_BD160_HLK.IFC
Time: 2022-04-10T19:23:19
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m
