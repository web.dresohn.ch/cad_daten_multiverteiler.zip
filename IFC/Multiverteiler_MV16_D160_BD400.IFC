Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Multiverteiler_MV16_D160_BD400.IFC
Time: 2022-08-11T20:18:53
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 93016_MV125_16AL
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 93036_MV125_16ZL
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 93053_MV125_VSW3_01 (2)
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 93060_MV_F55_links (2)
In: Default Storey
Material: 1060 Alloy

# IfcBuildingElementProxy: 93060_MV_F55_rechts (2)
In: Default Storey
Material: 1060 Alloy

# IfcBuildingElementProxy: 93070_MV_TB (2)
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 93136_a_MV125_16BD400
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 93136_b_MV125_16BD400
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: MirrorÜE 148x128_160
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: ÜE 148x128_160
In: Default Storey
Material: Steel
